# Keil uVision project quadrotor_test_bench.uvprojx, settings and files
target quadrotor_test_bench (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: quadrotor_test_bench +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Library/MotorLib;../Library/BaseLib;../Library/HMILib;../Library/EncoderLib;../Library/ForceSensorLib;../Library/RS485Bus
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Library/MotorLib
    ../Library/MotorLib/: HLS.c HLS.h INST.h SCS.c SCS.h SCSCL.c SCSCL.h SCSerail.c SCServo.h SMS_STS.c SMS_STS.h FTSerialConfig.c FTSerialConfig.h
  group Library/BaseLib
    ../Library/BaseLib/: MotorState.c MotorState.h ServoController.c ServoController.h MotorControl.c MotorControl.h
    ../Library/HMILib/: motor_data_converter.c motor_data_converter.h
  group Library/HMILib
    ../Library/HMILib/: HMIProtocol.c HMIProtocol.h HMIPacket.c HMIPacket.h HMISerial.c HMISerial.h HMICommandProtocol.c HMICommandProtocol.h
  group Library/RS485Bus
    ../Library/RS485Bus/: RS485Bus.c RS485Bus.h
  group Library/EncoderLib
    ../Library/EncoderLib/: EncoderSimple.c EncoderSimple.h
  group Library/ForceSensorLib
    ../Library/ForceSensorLib/: ForceSensor.c ForceSensor.h
software components: CMSIS:CORE 4.3.0
